<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>DNC2_hamming_decoder</key>
<param><key>id</key><value>DNC2_hamming_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>3</value></param>
</block>
<block>
<key>DNC2_hamming_decoder</key>
<param><key>id</key><value>DNC2_hamming_decoder_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>3</value></param>
</block>
<block>
<key>DNC2_hamming_decoder</key>
<param><key>id</key><value>DNC2_hamming_decoder_1</value></param>
<param><key>m</key><value>3</value></param>
</block>
<block>
<key>DNC2_hamming_decoder</key>
<param><key>id</key><value>DNC2_hamming_decoder_2</value></param>
<param><key>m</key><value>3</value></param>
</block>
<block>
<key>DNC2_hamming_encoder</key>
<param><key>id</key><value>DNC2_hamming_encoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>image_size</key><value>256*256</value></param>
<param><key>m</key><value>3</value></param>
<param><key>packet_size</key><value>3</value></param>
</block>
<block>
<key>DNC2_hamming_encoder</key>
<param><key>id</key><value>DNC2_hamming_encoder_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>image_size</key><value>256*256</value></param>
<param><key>m</key><value>3</value></param>
<param><key>packet_size</key><value>3</value></param>
</block>
<block>
<key>DNC2_hamming_encoder</key>
<param><key>id</key><value>DNC2_hamming_encoder_1</value></param>
<param><key>image_size</key><value>256*256</value></param>
<param><key>m</key><value>3</value></param>
<param><key>packet_size</key><value>64</value></param>
</block>
<block>
<key>DNC2_hamming_encoder</key>
<param><key>id</key><value>DNC2_hamming_encoder_2</value></param>
<param><key>image_size</key><value>256*256</value></param>
<param><key>m</key><value>3</value></param>
<param><key>packet_size</key><value>64</value></param>
</block>
<block>
<key>DNC2_image_vector_source</key>
<param><key>id</key><value>DNC2_image_vector_source_0_0</value></param>
<param><key>channel_coding</key><value>1</value></param>
<param><key>filename</key><value>/home/ubuntu/Downloads/lena_gray_256.txt</value></param>
<param><key>image_size</key><value>256*256</value></param>
<param><key>packet_size</key><value>64</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>tags</key><value>[]</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>DNC2_image_vector_source</key>
<param><key>id</key><value>DNC2_image_vector_source_0_0_0</value></param>
<param><key>channel_coding</key><value>1</value></param>
<param><key>filename</key><value>/home/ubuntu/Downloads/barbara_gray_256.txt</value></param>
<param><key>image_size</key><value>256*256</value></param>
<param><key>packet_size</key><value>64</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>tags</key><value>[]</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>DNC2_zero_elimination</key>
<param><key>id</key><value>DNC2_zero_elimination_0</value></param>
<param><key>data_len</key><value>64</value></param>
<param><key>node_id</key><value>120</value></param>
</block>
<block>
<key>DNC2_zero_elimination</key>
<param><key>id</key><value>DNC2_zero_elimination_0_0</value></param>
<param><key>data_len</key><value>64</value></param>
<param><key>node_id</key><value>121</value></param>
</block>
<block>
<key>DNC_check_received_packet</key>
<param><key>id</key><value>DNC_check_received_packet_0</value></param>
<param><key>check_node_id</key><value>122</value></param>
<param><key>data_size</key><value>64</value></param>
</block>
<block>
<key>DNC_check_received_packet</key>
<param><key>id</key><value>DNC_check_received_packet_0_0</value></param>
<param><key>check_node_id</key><value>122</value></param>
<param><key>data_size</key><value>64</value></param>
</block>
<block>
<key>DNC_end_node_control</key>
<param><key>id</key><value>DNC_end_node_control_0</value></param>
<param><key>data_size</key><value>64</value></param>
<param><key>end_node_id</key><value>121</value></param>
<param><key>relay_node_id</key><value>122</value></param>
</block>
<block>
<key>DNC_end_node_control</key>
<param><key>id</key><value>DNC_end_node_control_0_0</value></param>
<param><key>data_size</key><value>64</value></param>
<param><key>end_node_id</key><value>120</value></param>
<param><key>relay_node_id</key><value>122</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>25e3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0</value></param>
<param><key>const</key><value>25e3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_1</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_1_0</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>freq0</key><value>2.41475e9</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>bladerf=2a45</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0_1_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>freq0</key><value>2.41525e9</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>bladerf=3627</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2.425e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>comment</key><value>Node_A</value></param>
<param><key>args</key><value>bladerf=2a45</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_1_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2.425e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>comment</key><value>Node_B</value></param>
<param><key>args</key><value>bladerf=3627</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.2</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0_2</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0_2_0</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0_1</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0_1_0</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0_1</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0_1_0</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0_2</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>21</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0_2_0</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>21</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_ofdm_modulator</key>
<param><key>id</key><value>s4a_ofdm_modulator_0_1</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>21</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
</block>
<block>
<key>s4a_ofdm_modulator</key>
<param><key>id</key><value>s4a_ofdm_modulator_0_1_0</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>21</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>parallel_size</key><value>1008</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0_2</value></param>
<param><key>parallel_size</key><value>1008</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0_2_0</value></param>
<param><key>parallel_size</key><value>1008</value></param>
</block>
<block>
<key>show_image</key>
<param><key>id</key><value>show_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>imageheight</key><value>256</value></param>
<param><key>imagewidth</key><value>256</value></param>
</block>
<block>
<key>show_image</key>
<param><key>id</key><value>show_image_0</value></param>
<param><key>imageheight</key><value>256</value></param>
<param><key>imagewidth</key><value>256</value></param>
</block>
<connection><source_block_id>DNC2_hamming_decoder_0</source_block_id><sink_block_id>show_image_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_hamming_decoder_0_0</source_block_id><sink_block_id>show_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_hamming_decoder_1</source_block_id><sink_block_id>show_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_hamming_decoder_2</source_block_id><sink_block_id>show_image_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_hamming_encoder_1</source_block_id><sink_block_id>DNC_end_node_control_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DNC2_hamming_encoder_2</source_block_id><sink_block_id>DNC_end_node_control_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DNC2_image_vector_source_0_0</source_block_id><sink_block_id>DNC2_hamming_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_image_vector_source_0_0</source_block_id><sink_block_id>DNC2_hamming_encoder_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_image_vector_source_0_0_0</source_block_id><sink_block_id>DNC2_hamming_encoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_image_vector_source_0_0_0</source_block_id><sink_block_id>DNC2_hamming_encoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_zero_elimination_0</source_block_id><sink_block_id>DNC2_hamming_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_zero_elimination_0</source_block_id><sink_block_id>DNC2_hamming_decoder_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_zero_elimination_0_0</source_block_id><sink_block_id>DNC2_hamming_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_zero_elimination_0_0</source_block_id><sink_block_id>DNC2_hamming_decoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC_check_received_packet_0</source_block_id><sink_block_id>DNC_end_node_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC_check_received_packet_0_0</source_block_id><sink_block_id>DNC_end_node_control_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC_end_node_control_0</source_block_id><sink_block_id>s4a_byte_to_bit_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC_end_node_control_0</source_block_id><sink_block_id>DNC2_zero_elimination_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC_end_node_control_0_0</source_block_id><sink_block_id>s4a_byte_to_bit_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC_end_node_control_0_0</source_block_id><sink_block_id>DNC2_zero_elimination_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>s4a_ofdm_demodulator_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0</source_block_id><sink_block_id>s4a_ofdm_demodulator_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1</source_block_id><sink_block_id>dc_blocker_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_1_0</source_block_id><sink_block_id>dc_blocker_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0_2</source_block_id><sink_block_id>DNC_check_received_packet_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0_2_0</source_block_id><sink_block_id>DNC_check_received_packet_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0_1</source_block_id><sink_block_id>s4a_ofdm_modulator_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0_1_0</source_block_id><sink_block_id>s4a_ofdm_modulator_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0_1</source_block_id><sink_block_id>s4a_bpsk_mapper_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0_1_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_2</source_block_id><sink_block_id>blocks_null_sink_1_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_2</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_2</source_block_id><sink_block_id>s4a_parallel_to_serial_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_2_0</source_block_id><sink_block_id>blocks_null_sink_1_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_2_0</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_2_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_modulator_0_1</source_block_id><sink_block_id>osmosdr_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_modulator_0_1_0</source_block_id><sink_block_id>osmosdr_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0_2</source_block_id><sink_block_id>s4a_bpsk_demapper_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0_2_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
