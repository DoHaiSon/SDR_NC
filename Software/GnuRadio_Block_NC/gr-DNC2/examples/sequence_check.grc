<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutPos</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15)</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>hoang_sequence_splitting</key>
<param><key>id</key><value>hoang_sequence_splitting_0</value></param>
<param><key>cut_position</key><value>4</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>seq</value></param>
<param><key>sequence_length</key><value>16 - cutPos</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>seq</value></param>
<param><key>sequence_length</key><value>cutPos</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<connection><source_block_id>hoang_sequence_splitting_0</source_block_id><sink_block_id>s4a_console_sink_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>hoang_sequence_splitting_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hoang_sequence_splitting_0</source_block_id><sink_block_id>s4a_console_sink_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
