<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>(0x01,0xAA)</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>s4a_qam4_mapper</key>
<param><key>id</key><value>s4a_qam4_mapper_0</value></param>
</block>
<block>
<key>s4a_qam4_demapper</key>
<param><key>id</key><value>s4a_qam4_demapper_0</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>seq</value></param>
<param><key>sequence_length</key><value>2</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<connection><source_block_id>s4a_qam4_mapper_0</source_block_id><sink_block_id>s4a_qam4_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_qam4_demapper_0</source_block_id><sink_block_id>s4a_console_sink_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>s4a_qam4_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
