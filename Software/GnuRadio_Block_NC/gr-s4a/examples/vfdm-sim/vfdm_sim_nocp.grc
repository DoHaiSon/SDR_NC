<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_sz</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_t_sz</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>precoder_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_max</value></param>
<param><key>value</key><value>32768</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0</value></param>
<param><key>parallel_size</key><value>(precoder_length + fft_length)</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_0</value></param>
<param><key>parallel_size</key><value>precoder_length</value></param>
</block>
<block>
<key>s4a_vfdm_power_scaling</key>
<param><key>id</key><value>s4a_vfdm_power_scaling_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/0.8964</value></param>
<param><key>data_coeff</key><value>1/0.8964</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>1</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/vfdm_tx.dump</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>s4a_vfdm_precoder</key>
<param><key>id</key><value>s4a_vfdm_precoder_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>1</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_2</value></param>
<param><key>parallel_size</key><value>occupied_tones</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>parallel_size</key><value>(data_block_sz*precoder_length)</value></param>
</block>
<block>
<key>s4a_vfdm_sync</key>
<param><key>id</key><value>s4a_vfdm_sync_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>cfo_next_preamble_distance</key><value>1</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>(1,0.4,0.3)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_1</value></param>
<param><key>parallel_size</key><value>(fft_length + cp_length)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>(fft_length + cp_length)</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>s4a_vfdm_equalizer</key>
<param><key>id</key><value>s4a_vfdm_equalizer_0</value></param>
<param><key>fft_length</key><value>(fft_length + cp_length)</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>1</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1_0_0</value></param>
<param><key>parallel_size</key><value>16</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0_0</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>equalized</value></param>
<param><key>sequence_length</key><value>16</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>hoang_int_to_char</key>
<param><key>id</key><value>hoang_int_to_char_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>144</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>demodulated</value></param>
<param><key>sequence_length</key><value>16</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>s4a_coherence_time_counter_generator</key>
<param><key>id</key><value>s4a_coherence_time_counter_generator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>packet_header_sz</key><value>8</value></param>
<param><key>packet_header_val</key><value>0x0</value></param>
<param><key>packet_counter_sz</key><value>8</value></param>
<param><key>packet_rep</key><value>1</value></param>
<param><key>packet_zero_padding</key><value>0</value></param>
</block>
<block>
<key>hoang_image_vector_source</key>
<param><key>id</key><value>hoang_image_vector_source_0_0</value></param>
<param><key>filename</key><value>/home/khachoang/GNU_Radio/test_grc/repeat_6.txt</value></param>
<param><key>image_size</key><value>6*100</value></param>
<param><key>tags</key><value>[]</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0</value></param>
</block>
<block>
<key>s4a_coherence_time_estimator</key>
<param><key>id</key><value>s4a_coherence_time_estimator_0</value></param>
<param><key>channel_sz</key><value>(precoder_length*(fft_length + cp_length))</value></param>
<param><key>data_sz</key><value>precoder_length</value></param>
<param><key>output_mode</key><value>2</value></param>
<param><key>pearson_correlation</key><value>1</value></param>
<param><key>check_sz</key><value>1</value></param>
<param><key>r_differentiation</key><value>0</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>snr_threshold</key><value>7</value></param>
<param><key>frame_sz</key><value>(fft_length + cp_length)*(preamble_block_rep + pilot_block_t_sz*pilot_block_rep + data_block_rep + silence_block_rep)</value></param>
<param><key>signal_bw</key><value>1000000</value></param>
<param><key>packet_header_sz</key><value>8</value></param>
<param><key>packet_header_val</key><value>0x0</value></param>
<param><key>packet_counter_sz</key><value>8</value></param>
<param><key>packet_rep</key><value>1</value></param>
<param><key>packet_zero_padding</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>(precoder_length*(fft_length + cp_length))</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>s4a_vfdm_precoder_0</source_block_id><sink_block_id>s4a_vfdm_power_scaling_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_power_scaling_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>s4a_serial_to_parallel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_0</source_block_id><sink_block_id>s4a_vfdm_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_2</source_block_id><sink_block_id>s4a_vfdm_precoder_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>s4a_serial_to_parallel_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_sync_0</source_block_id><sink_block_id>s4a_serial_to_parallel_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>s4a_vfdm_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_coherence_time_counter_generator_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_coherence_time_estimator_0</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>s4a_coherence_time_estimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>s4a_coherence_time_estimator_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>s4a_coherence_time_estimator_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>s4a_coherence_time_estimator_0</source_block_id><sink_block_id>blocks_null_sink_0_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1_0</source_block_id><sink_block_id>blocks_null_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_coherence_time_estimator_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_1</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>s4a_vfdm_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0_0</source_block_id><sink_block_id>s4a_console_sink_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1_0_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_coherence_time_estimator_0</source_block_id><sink_block_id>hoang_int_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hoang_int_to_char_0</source_block_id><sink_block_id>s4a_console_sink_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hoang_image_vector_source_0_0</source_block_id><sink_block_id>s4a_byte_to_bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
