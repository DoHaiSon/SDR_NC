<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3200000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/out.dump</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>6</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>parallel_size</key><value>48</value></param>
</block>
<block>
<key>s4a_zero_padding</key>
<param><key>id</key><value>s4a_zero_padding_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>input_stream_length</key><value>(128+ 16)*(1 + 1 + 1 + 1)</value></param>
<param><key>output_stream_length</key><value>128*5</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/metrics_master.dump</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>(4+48)</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/cp_test.dump</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_power</value></param>
<param><key>label</key><value>Transmit Power</value></param>
<param><key>value</key><value>2500</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/out.dump</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate/3200</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>-1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000), -1.0000+1j*(0.0000), 1.0000+1j*(0.0000)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>parallel_size</key><value>48</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2.422e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>1</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
<param><key>timeout_ms</key><value>1</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>1.0086-0.7621j,0.9668-0.8128j,0.9781-0.8767j,0.9430-0.9825j,0.8753-1.0319j,0.8574-1.0759j,0.8097-1.1702j,0.7052-1.2219j,0.6291-1.2288j,0.5623-1.2482j,0.4859-1.2443j,0.4425-1.2353j,0.3860-1.2571j,0.2984-1.2465j,0.2472-1.2099j,0.2007-1.2069j,0.1146-1.1829j,0.0580-1.1095j,0.0472-1.0575j,0.0232-1.0348j,-0.0156-1.0027j,-0.0530-0.9659j,-0.1030-0.9230j,-0.1568-0.8458j,-0.1704-0.7367j,-0.1296-0.6523j,-0.0978-0.6237j,-0.1141-0.5839j,-0.1093-0.4980j,-0.0617-0.4358j,-0.0385-0.3992j,-0.0202-0.3280j,0.0423-0.2591j,0.1028-0.2250j,0.1484-0.1781j,0.2238-0.1205j,0.3226-0.0885j,0.4254-0.0821j,0.5222-0.1036j,0.5940-0.1359j,0.6624-0.1534j,0.7517-0.1794j,0.8460-0.2359j,0.9262-0.3290j,0.9524-0.4448j,0.9339-0.5092j,0.9702-0.5351j,1.0335-0.6359j</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate/32000</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>6</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vector</key><value>25</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate/32000</value></param>
</block>
<block>
<key>s4a_secondary_user_tx_controller</key>
<param><key>id</key><value>s4a_secondary_user_tx_controller_0</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>required_data_bytes_on_each_burst</key><value>6</value></param>
<param><key>working_mode</key><value>0</value></param>
<param><key>symbol_flow</key><value>0</value></param>
<param><key>node_id</key><value>187</value></param>
<param><key>remote_node_id</key><value>170</value></param>
<param><key>response_timeout_ms</key><value>10</value></param>
<param><key>wrong_packet_discard_limit</key><value>4</value></param>
<param><key>tx_packet_repetition</key><value>1</value></param>
<param><key>snr_limit</key><value>7.0</value></param>
<param><key>snr_console_print_rate</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>6</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_0</value></param>
<param><key>parallel_size</key><value>48</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1</value></param>
<param><key>parallel_size</key><value>48</value></param>
</block>
<block>
<key>s4a_ofdm_modulator</key>
<param><key>id</key><value>s4a_ofdm_modulator_0</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>pilot_block_rep</key><value>33</value></param>
<param><key>data_block_sz</key><value>1</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2422e6</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_csi_converter</key>
<param><key>id</key><value>s4a_csi_converter_0</value></param>
<param><key>data_syms_length</key><value>48</value></param>
<param><key>channel_size</key><value>48</value></param>
</block>
<block>
<key>s4a_vfdm_modulator</key>
<param><key>id</key><value>s4a_vfdm_modulator_0</value></param>
<param><key>fft_length</key><value>128</value></param>
<param><key>occupied_tones</key><value>48</value></param>
<param><key>cp_length</key><value>16</value></param>
<param><key>precoder_length</key><value>16</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>preamble_block_rep</key><value>1</value></param>
<param><key>pilot_block_t_sz</key><value>31</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>3</value></param>
<param><key>data_block_rep</key><value>1</value></param>
<param><key>silence_block_rep</key><value>1</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/2.1513</value></param>
<param><key>data_coeff</key><value>1/2.1513</value></param>
</block>
<block>
<key>s4a_active_stream_selector</key>
<param><key>id</key><value>s4a_active_stream_selector_0</value></param>
<param><key>first_stream_length</key><value>(128+16)*(1+33 +1 +1 )</value></param>
<param><key>second_stream_length</key><value>(128 + 16)*(1 + 31 + 3 + 1)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>tx_power</value></param>
</block>
<connection><source_block_id>s4a_active_stream_selector_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>blocks_file_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_csi_converter_0</source_block_id><sink_block_id>s4a_vfdm_modulator_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>s4a_ofdm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_modulator_0</source_block_id><sink_block_id>s4a_active_stream_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_csi_converter_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>s4a_csi_converter_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_vfdm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_csi_converter_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_active_stream_selector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_modulator_0</source_block_id><sink_block_id>s4a_active_stream_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>s4a_serial_to_parallel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_0</source_block_id><sink_block_id>s4a_csi_converter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>s4a_zero_padding_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>s4a_byte_to_bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>s4a_ofdm_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
