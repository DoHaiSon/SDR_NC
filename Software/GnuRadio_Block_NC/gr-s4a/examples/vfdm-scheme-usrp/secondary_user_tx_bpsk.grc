<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>precoder_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_t_sz</value></param>
<param><key>value</key><value>33</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_sz</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_rep</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_power</value></param>
<param><key>label</key><value>Transmit Power</value></param>
<param><key>value</key><value>25000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/out.dump</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>s4a_ofdm_equalizer</key>
<param><key>id</key><value>s4a_ofdm_equalizer_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(occupied_tones/8)*data_block_sz</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_0</value></param>
<param><key>parallel_size</key><value>(occupied_tones)*data_block_sz</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(occupied_tones/8)*data_block_sz</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>(occupied_tones*data_block_sz)</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/out.dump</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/h21.dump</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>occupied_tones</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>64</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_secondary_user_tx_controller</key>
<param><key>id</key><value>s4a_secondary_user_tx_controller_0</value></param>
<param><key>channel_size</key><value>occupied_tones</value></param>
<param><key>required_data_bytes_on_each_burst</key><value>(occupied_tones/8)*data_block_sz</value></param>
<param><key>working_mode</key><value>1</value></param>
<param><key>symbol_flow</key><value>1</value></param>
<param><key>node_id</key><value>187</value></param>
<param><key>remote_node_id</key><value>170</value></param>
<param><key>response_timeout_ms</key><value>10</value></param>
<param><key>wrong_packet_discard_limit</key><value>1000</value></param>
<param><key>tx_packet_repetition</key><value>1</value></param>
<param><key>snr_limit</key><value>10</value></param>
<param><key>snr_console_print_rate</key><value>1</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0</value></param>
<param><key>parallel_size</key><value>occupied_tones*data_block_sz</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_1</value></param>
<param><key>parallel_size</key><value>fft_length + cp_length</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/out.dump</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>s4a_cyclic_prefix_removal</key>
<param><key>id</key><value>s4a_cyclic_prefix_removal_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>25000</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2.422e9</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>bb_gain0</key><value>3</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>tx_power</value></param>
</block>
<block>
<key>s4a_vfdm_modulator</key>
<param><key>id</key><value>s4a_vfdm_modulator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>channel_size</key><value>occupied_tones</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>data_block_sz*(occupied_tones/precoder_length)</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/2.1513</value></param>
<param><key>data_coeff</key><value>1/1.872</value></param>
</block>
<block>
<key>s4a_vfdm_power_scaling</key>
<param><key>id</key><value>s4a_vfdm_power_scaling_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/0.8964</value></param>
<param><key>data_coeff</key><value>1/0.8964</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_vfdm_precoder</key>
<param><key>id</key><value>s4a_vfdm_precoder_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>seq</value></param>
<param><key>sequence_length</key><value>6</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>s4a_ofdm_sync</key>
<param><key>id</key><value>s4a_ofdm_sync_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>cfo_next_preamble_distance</key><value>1</value></param>
<param><key>timeout_ms</key><value>1</value></param>
<param><key>cfo_sync_method</key><value>1</value></param>
</block>
<block>
<key>s4a_ofdm_modulator</key>
<param><key>id</key><value>s4a_ofdm_modulator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>data_coeff</key><value>1/24.0</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>parallel_size</key><value>(occupied_tones)*data_block_sz</value></param>
</block>
<block>
<key>s4a_vfdm_metrics_controller</key>
<param><key>id</key><value>s4a_vfdm_metrics_controller_0</value></param>
<param><key>data_syms_length</key><value>(occupied_tones)*data_block_sz</value></param>
<param><key>channel_size</key><value>occupied_tones</value></param>
<param><key>normalize_h</key><value>1</value></param>
</block>
<block>
<key>s4a_frame_generation</key>
<param><key>id</key><value>s4a_frame_generation_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>[]</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>s4a_ofdm_power_scaling</key>
<param><key>id</key><value>s4a_ofdm_power_scaling_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0_0</value></param>
<param><key>parallel_size</key><value>(precoder_length + fft_length)</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0_1</value></param>
<param><key>parallel_size</key><value>fft_length + cp_length</value></param>
</block>
<block>
<key>s4a_active_stream_selector</key>
<param><key>id</key><value>s4a_active_stream_selector_0</value></param>
<param><key>first_stream_length</key><value>(fft_length + cp_length)*(preamble_block_rep + pilot_block_rep + data_block_sz*data_block_rep + silence_block_rep)</value></param>
<param><key>second_stream_length</key><value>(fft_length + precoder_length)*(preamble_block_rep + pilot_block_t_sz + data_block_sz*(occupied_tones/precoder_length) + silence_block_rep)</value></param>
</block>
<block>
<key>s4a_zero_padding</key>
<param><key>id</key><value>s4a_zero_padding_1</value></param>
<param><key>input_stream_length</key><value>(fft_length + cp_length)*(preamble_block_rep + pilot_block_rep + data_block_sz*data_block_rep + silence_block_rep)</value></param>
<param><key>output_stream_length</key><value>(fft_length + cp_length)*(preamble_block_rep + pilot_block_rep + data_block_sz*data_block_rep + silence_block_rep) + (128 - ((fft_length + cp_length)*(preamble_block_rep + pilot_block_rep + data_block_sz*data_block_rep + silence_block_rep) % 128))</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2422e6</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>bb_gain0</key><value>3</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0_0_0</value></param>
<param><key>parallel_size</key><value>48</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_0_0</value></param>
<param><key>parallel_size</key><value>precoder_length</value></param>
</block>
<block>
<key>s4a_cyclic_prefix_insertion</key>
<param><key>id</key><value>s4a_cyclic_prefix_insertion_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_1</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_active_stream_selector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_0</source_block_id><sink_block_id>s4a_vfdm_metrics_controller_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>s4a_vfdm_modulator_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_ofdm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_modulator_0</source_block_id><sink_block_id>s4a_active_stream_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>s4a_zero_padding_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_zero_padding_1</source_block_id><sink_block_id>blocks_file_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>blocks_file_sink_2_0_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>s4a_byte_to_bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>s4a_serial_to_parallel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_sync_0</source_block_id><sink_block_id>s4a_serial_to_parallel_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_1</source_block_id><sink_block_id>s4a_cyclic_prefix_removal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>s4a_secondary_user_tx_controller_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>s4a_ofdm_sync_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_cyclic_prefix_removal_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>s4a_ofdm_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_secondary_user_tx_controller_0</source_block_id><sink_block_id>s4a_vfdm_metrics_controller_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_ofdm_modulator_0</source_block_id><sink_block_id>s4a_active_stream_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_zero_padding_1</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>s4a_ofdm_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_zero_padding_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_active_stream_selector_0</source_block_id><sink_block_id>s4a_zero_padding_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_precoder_0</source_block_id><sink_block_id>s4a_vfdm_power_scaling_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_power_scaling_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>s4a_vfdm_precoder_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0_0_0</source_block_id><sink_block_id>s4a_serial_to_parallel_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_0_0</source_block_id><sink_block_id>s4a_vfdm_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0_0</source_block_id><sink_block_id>s4a_active_stream_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>s4a_console_sink_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_power_scaling_0</source_block_id><sink_block_id>s4a_cyclic_prefix_insertion_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_cyclic_prefix_insertion_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>s4a_ofdm_power_scaling_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_frame_generation_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_metrics_controller_0</source_block_id><sink_block_id>s4a_frame_generation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0_1</source_block_id><sink_block_id>s4a_active_stream_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
