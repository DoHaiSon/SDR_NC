<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_max</value></param>
<param><key>value</key><value>32768</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/txt.dump</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>occupied_tones</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_1</value></param>
<param><key>parallel_size</key><value>fft_length + cp_length</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_sz</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1_1_0_2</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/ejder.dump</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>128</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>rx_bits</value></param>
<param><key>sequence_length</key><value>((occupied_tones*data_block_sz)/8)</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1</value></param>
<param><key>parallel_size</key><value>(data_block_sz*occupied_tones)</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sequence_name</key><value>rx_bits</value></param>
<param><key>sequence_length</key><value>48</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_rep</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>s4a_ofdm_sync</key>
<param><key>id</key><value>s4a_ofdm_sync_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>cfo_next_preamble_distance</key><value>1</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/ejder/Desktop/gr-s4a/scripts/ofdm.dump</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>s4a_cyclic_prefix_removal</key>
<param><key>id</key><value>s4a_cyclic_prefix_removal_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>s4a_ofdm_equalizer</key>
<param><key>id</key><value>s4a_ofdm_equalizer_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>s4a_console_sink_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_1</source_block_id><sink_block_id>s4a_cyclic_prefix_removal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_sync_0</source_block_id><sink_block_id>s4a_serial_to_parallel_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>s4a_ofdm_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_console_sink_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_cyclic_prefix_removal_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>s4a_ofdm_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
