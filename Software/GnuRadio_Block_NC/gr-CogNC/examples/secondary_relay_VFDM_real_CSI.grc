<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>precoder_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ofdm_data_block_sz</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vfdm_pilot_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ofdm_pilot_block_rep</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_t_sz</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vfdm_data_block_sz</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Relay Node RX</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>-250e3</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>25e3</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>250e3</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>0.2e6</value></param>
<param><key>width</key><value>0.05e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>0.2e6</value></param>
<param><key>width</key><value>0.05e6</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1_0</value></param>
<param><key>parallel_size</key><value>(ofdm_data_block_sz*occupied_tones)</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1</value></param>
<param><key>parallel_size</key><value>ofdm_data_block_sz*occupied_tones</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>occupied_tones</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0</value></param>
</block>
<block>
<key>s4a_vfdm_power_scaling</key>
<param><key>id</key><value>s4a_vfdm_power_scaling_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/0.8964</value></param>
<param><key>data_coeff</key><value>1/0.8964</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>vfdm_pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>vfdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>CogNC_hybrid_stream_control</key>
<param><key>id</key><value>CogNC_hybrid_stream_control_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>ofdm_stream_length</key><value>(fft_length+cp_length)*(preamble_block_rep+ofdm_data_block_sz*data_block_rep+ofdm_pilot_block_rep+silence_block_rep)</value></param>
<param><key>vfdm_stream_length</key><value>(fft_length+precoder_length)*(preamble_block_rep+vfdm_data_block_sz*data_block_rep+pilot_block_t_sz*vfdm_pilot_block_rep+silence_block_rep)</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>bladerf=1</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2.415e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>bb_gain0</key><value>3</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2.425e9</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>bb_gain0</key><value>3</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>ofdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>data_block_sz</key><value>ofdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0_0</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>s4a_ofdm_modulator</key>
<param><key>id</key><value>s4a_ofdm_modulator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>ofdm_pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>ofdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>6</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>CogNC_primary_source_control</key>
<param><key>id</key><value>CogNC_primary_source_control_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>packet_size</key><value>256</value></param>
<param><key>source_id</key><value>187</value></param>
<param><key>destination_id</key><value>170</value></param>
<param><key>ack_burst_size</key><value>6</value></param>
<param><key>channel_size</key><value>48</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>2.435e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>6</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>bb_gain0</key><value>3</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
</block>
<block>
<key>DNC2_image_vector_source</key>
<param><key>id</key><value>DNC2_image_vector_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>filename</key><value>/home/ssl-lap1/sandbox/gnuradio-builds/Test_4nodes/lena_gray_256.txt</value></param>
<param><key>image_size</key><value>256</value></param>
<param><key>packet_size</key><value>256</value></param>
<param><key>tags</key><value>[]</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>channel_coding</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_rep</key><value>ofdm_pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>ofdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>parallel_size</key><value>ofdm_data_block_sz*occupied_tones</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>25e3</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>[1.0086-0.7621j,0.9668-0.8128j,0.9781-0.8767j,0.9430-0.9825j,0.8753-1.0319j,0.8574-1.0759j,0.8097-1.1702j,0.7052-1.2219j,0.6291-1.2288j,0.5623-1.2482j,0.4859-1.2443j,0.4425-1.2353j,0.3860-1.2571j,0.2984-1.2465j,0.2472-1.2099j,0.2007-1.2069j,0.1146-1.1829j,0.0580-1.1095j,0.0472-1.0575j,0.0232-1.0348j,-0.0156-1.0027j,-0.0530-0.9659j,-0.1030-0.9230j,-0.1568-0.8458j,-0.1704-0.7367j,-0.1296-0.6523j,-0.0978-0.6237j,-0.1141-0.5839j,-0.1093-0.4980j,-0.0617-0.4358j,-0.0385-0.3992j,-0.0202-0.3280j,0.0423-0.2591j,0.1028-0.2250j,0.1484-0.1781j,0.2238-0.1205j,0.3226-0.0885j,0.4254-0.0821j,0.5222-0.1036j,0.5940-0.1359j,0.6624-0.1534j,0.7517-0.1794j,0.8460-0.2359j,0.9262-0.3290j,0.9524-0.4448j,0.9339-0.5092j,0.9702-0.5351j,1.0335-0.6359j]</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>s4a_vfdm_precoder</key>
<param><key>id</key><value>s4a_vfdm_precoder_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>vfdm_pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>vfdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_0_0</value></param>
<param><key>parallel_size</key><value>60*8</value></param>
</block>
<block>
<key>CogNC_vfdm_metrics_control</key>
<param><key>id</key><value>CogNC_vfdm_metrics_control_0</value></param>
<param><key>data_symbol_length</key><value>60*8</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>normalize_channel</key><value>1</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0</value></param>
<param><key>parallel_size</key><value>(precoder_length + fft_length)</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>20000</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0_0</value></param>
<param><key>parallel_size</key><value>60*8</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_2</value></param>
<param><key>parallel_size</key><value>16</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>(precoder_length*(fft_length+cp_length))</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_1</value></param>
<param><key>parallel_size</key><value>fft_length + cp_length</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0_0_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>s4a_vfdm_equalizer</key>
<param><key>id</key><value>s4a_vfdm_equalizer_0</value></param>
<param><key>fft_length</key><value>(fft_length+cp_length)</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>vfdm_pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>vfdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>CogNC_flow_filling</key>
<param><key>id</key><value>CogNC_flow_filling_0</value></param>
<param><key>buffer_sz</key><value>1</value></param>
</block>
<block>
<key>s4a_vfdm_sync</key>
<param><key>id</key><value>s4a_vfdm_sync_0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>precoder_length</key><value>precoder_length</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>pilot_block_t_sz</key><value>pilot_block_t_sz</value></param>
<param><key>pilot_block_rep</key><value>vfdm_pilot_block_rep</value></param>
<param><key>data_block_sz</key><value>vfdm_data_block_sz</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>cfo_next_preamble_distance</key><value>1</value></param>
<param><key>time_out</key><value>1000</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1_0_0</value></param>
<param><key>parallel_size</key><value>(precoder_length*vfdm_data_block_sz)</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>sequence_name</key><value>equalized</value></param>
<param><key>sequence_length</key><value>vfdm_data_block_sz*2</value></param>
<param><key>print_rate</key><value>1</value></param>
</block>
<block>
<key>CogNC_secondary_relay_control</key>
<param><key>id</key><value>CogNC_secondary_relay_control_0</value></param>
<param><key>packet_size</key><value>54</value></param>
<param><key>buffer_size</key><value>50</value></param>
<param><key>$guard_interval_downlink</key><value>0</value></param>
<param><key>guard_interval</key><value>6</value></param>
<param><key>end_nodeA_id</key><value>120</value></param>
<param><key>end_nodeB_id</key><value>121</value></param>
<param><key>relay_id</key><value>122</value></param>
</block>
<connection><source_block_id>s4a_parallel_to_serial_1_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_0</source_block_id><sink_block_id>blocks_null_sink_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>s4a_ofdm_demodulator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>s4a_ofdm_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_precoder_0</source_block_id><sink_block_id>s4a_vfdm_power_scaling_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0_0</source_block_id><sink_block_id>s4a_ofdm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>s4a_serial_to_parallel_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_0_0</source_block_id><sink_block_id>CogNC_vfdm_metrics_control_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>CogNC_hybrid_stream_control_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>CogNC_hybrid_stream_control_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_ofdm_modulator_0</source_block_id><sink_block_id>CogNC_hybrid_stream_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_power_scaling_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>CogNC_flow_filling_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_flow_filling_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0_0</source_block_id><sink_block_id>CogNC_secondary_relay_control_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>CogNC_secondary_relay_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_secondary_relay_control_0</source_block_id><sink_block_id>s4a_byte_to_bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_primary_source_control_0</source_block_id><sink_block_id>s4a_byte_to_bit_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>CogNC_vfdm_metrics_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_primary_source_control_0</source_block_id><sink_block_id>blocks_null_sink_0_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>CogNC_primary_source_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_1</source_block_id><sink_block_id>CogNC_primary_source_control_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DNC2_image_vector_source_0</source_block_id><sink_block_id>CogNC_primary_source_control_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>CogNC_primary_source_control_0</source_block_id><sink_block_id>blocks_null_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_1</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1_1</source_block_id><sink_block_id>s4a_bpsk_demapper_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>s4a_ofdm_demodulator_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0_1</source_block_id><sink_block_id>s4a_parallel_to_serial_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_2</source_block_id><sink_block_id>s4a_vfdm_precoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_vfdm_metrics_control_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_vfdm_metrics_control_0</source_block_id><sink_block_id>s4a_vfdm_precoder_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0_0</source_block_id><sink_block_id>s4a_serial_to_parallel_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_flow_filling_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0_0_0</source_block_id><sink_block_id>s4a_console_sink_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>blocks_null_sink_0_2_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1_0_0</source_block_id><sink_block_id>s4a_bpsk_demapper_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>blocks_null_sink_0_1_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_equalizer_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_1</source_block_id><sink_block_id>s4a_vfdm_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_vfdm_sync_0</source_block_id><sink_block_id>s4a_serial_to_parallel_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_flow_filling_0</source_block_id><sink_block_id>s4a_vfdm_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
