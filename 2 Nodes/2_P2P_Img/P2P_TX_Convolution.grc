<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_sz</value></param>
<param><key>value</key><value>21</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>img_size</value></param>
<param><key>value</key><value>512</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>CogNC_flow_filling</key>
<param><key>id</key><value>CogNC_flow_filling_0</value></param>
<param><key>buffer_sz</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>CogNC_primary_tx_control</key>
<param><key>id</key><value>CogNC_primary_tx_control_0</value></param>
<param><key>ack_burst_size</key><value>6</value></param>
<param><key>channel_size</key><value>48</value></param>
<param><key>destination_id</key><value>170</value></param>
<param><key>guard_interval</key><value>6</value></param>
<param><key>packet_sz</key><value>data_size</value></param>
<param><key>source_id</key><value>187</value></param>
</block>
<block>
<key>DNC2_convolutional_encoder</key>
<param><key>id</key><value>DNC2_convolutional_encoder_0</value></param>
<param><key>gen1</key><value>[1, 1, 1]</value></param>
<param><key>gen2</key><value>[1, 0, 1]</value></param>
<param><key>image_size</key><value>img_size * img_size</value></param>
<param><key>packet_size</key><value>data_size</value></param>
</block>
<block>
<key>DNC2_image_vector_source</key>
<param><key>id</key><value>DNC2_image_vector_source_0</value></param>
<param><key>channel_coding</key><value>1</value></param>
<param><key>filename</key><value>/home/ubuntu/SDR_NC/2 Nodes/2_P2P_Img/lena_gray_512.txt</value></param>
<param><key>image_size</key><value>img_size * img_size</value></param>
<param><key>packet_size</key><value>data_size</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>tags</key><value>[]</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>25e3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>occupied_tones</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>6</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>freq0</key><value>2.55e9</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>bladerf=2a45</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2.515e9</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value>bladerf=2a45</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0</value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0</value></param>
</block>
<block>
<key>s4a_ofdm_demodulator</key>
<param><key>id</key><value>s4a_ofdm_demodulator_0</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>data_block_sz</key><value>1</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_ofdm_modulator</key>
<param><key>id</key><value>s4a_ofdm_modulator_0</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>pilot_block_rep</key><value>1</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1</value></param>
<param><key>parallel_size</key><value>occupied_tones</value></param>
</block>
<connection><source_block_id>CogNC_primary_tx_control_0</source_block_id><sink_block_id>s4a_byte_to_bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CogNC_primary_tx_control_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DNC2_convolutional_encoder_0</source_block_id><sink_block_id>CogNC_primary_tx_control_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>DNC2_image_vector_source_0</source_block_id><sink_block_id>DNC2_convolutional_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>s4a_ofdm_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>CogNC_primary_tx_control_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>s4a_ofdm_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>CogNC_primary_tx_control_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_demodulator_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_modulator_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
