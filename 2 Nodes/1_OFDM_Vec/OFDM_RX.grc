<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_sz</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>25000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>occupied_tones</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_1</value></param>
<param><key>length</key><value>256</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>1.5e6</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>2415e6+0*250e3</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>s4a_bpsk_demapper</key>
<param><key>id</key><value>s4a_bpsk_demapper_0</value></param>
</block>
<block>
<key>s4a_console_sink_xx</key>
<param><key>id</key><value>s4a_console_sink_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>print_rate</key><value>1</value></param>
<param><key>sequence_length</key><value>600</value></param>
<param><key>sequence_name</key><value>rx_bits</value></param>
</block>
<block>
<key>s4a_cyclic_prefix_removal</key>
<param><key>id</key><value>s4a_cyclic_prefix_removal_0</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
</block>
<block>
<key>s4a_ofdm_equalizer</key>
<param><key>id</key><value>s4a_ofdm_equalizer_0</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>verbose</key><value>0</value></param>
</block>
<block>
<key>s4a_ofdm_sync</key>
<param><key>id</key><value>s4a_ofdm_sync_0</value></param>
<param><key>cfo_next_preamble_distance</key><value>1</value></param>
<param><key>cfo_sync_method</key><value>0</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
<param><key>timeout_ms</key><value>1000</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_1</value></param>
<param><key>parallel_size</key><value>(data_block_sz*occupied_tones)</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_1</value></param>
<param><key>parallel_size</key><value>fft_length + cp_length</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>s4a_ofdm_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>s4a_ofdm_equalizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_demapper_0</source_block_id><sink_block_id>s4a_console_sink_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_cyclic_prefix_removal_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_equalizer_0</source_block_id><sink_block_id>s4a_parallel_to_serial_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_sync_0</source_block_id><sink_block_id>s4a_serial_to_parallel_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_1</source_block_id><sink_block_id>s4a_bpsk_demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_1</source_block_id><sink_block_id>s4a_cyclic_prefix_removal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
