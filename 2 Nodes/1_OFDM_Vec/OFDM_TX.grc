<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cp_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_block_sz</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_length</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_tones</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_block_rep</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>silence_block_rep</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1,2,3,4,5,6,)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_length</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>2.415e9 </value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>s4a_bpsk_mapper</key>
<param><key>id</key><value>s4a_bpsk_mapper_0</value></param>
</block>
<block>
<key>s4a_byte_to_bit</key>
<param><key>id</key><value>s4a_byte_to_bit_0</value></param>
</block>
<block>
<key>s4a_cyclic_prefix_insertion</key>
<param><key>id</key><value>s4a_cyclic_prefix_insertion_0</value></param>
<param><key>cp_length</key><value>cp_length</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
</block>
<block>
<key>s4a_frame_generation</key>
<param><key>id</key><value>s4a_frame_generation_0</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>occupied_tones</key><value>occupied_tones</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_ofdm_power_scaling</key>
<param><key>id</key><value>s4a_ofdm_power_scaling_0</value></param>
<param><key>data_block_rep</key><value>data_block_rep</value></param>
<param><key>data_block_sz</key><value>data_block_sz</value></param>
<param><key>data_coeff</key><value>1/48.0</value></param>
<param><key>fft_length</key><value>fft_length</value></param>
<param><key>pilot_block_rep</key><value>pilot_block_rep</value></param>
<param><key>pilot_coeff</key><value>1/13.9017</value></param>
<param><key>preamble_block_rep</key><value>preamble_block_rep</value></param>
<param><key>preamble_coeff</key><value>1/9.6571</value></param>
<param><key>silence_block_rep</key><value>silence_block_rep</value></param>
</block>
<block>
<key>s4a_parallel_to_serial</key>
<param><key>id</key><value>s4a_parallel_to_serial_0</value></param>
<param><key>parallel_size</key><value>fft_length + cp_length</value></param>
</block>
<block>
<key>s4a_serial_to_parallel</key>
<param><key>id</key><value>s4a_serial_to_parallel_0</value></param>
<param><key>parallel_size</key><value>occupied_tones</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>s4a_byte_to_bit_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>s4a_ofdm_power_scaling_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_bpsk_mapper_0</source_block_id><sink_block_id>s4a_serial_to_parallel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_byte_to_bit_0</source_block_id><sink_block_id>s4a_bpsk_mapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_cyclic_prefix_insertion_0</source_block_id><sink_block_id>s4a_parallel_to_serial_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_frame_generation_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_ofdm_power_scaling_0</source_block_id><sink_block_id>s4a_cyclic_prefix_insertion_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_parallel_to_serial_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s4a_serial_to_parallel_0</source_block_id><sink_block_id>s4a_frame_generation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
